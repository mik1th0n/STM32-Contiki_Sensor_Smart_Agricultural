# Keil uVision project iSO-STM32.uvprojx, settings and files
target WF-ESP8266 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\gpio;..\..\User\SysTick;..\..\User\usart;..\..\User\DMA;..\..\User\contiki-code\cpu\arm\stm32f103;..\..\User\contiki-code\platform\stm32test;..\..\User\contiki-code\core;..\..\User\contiki-code\core\sys;..\..\User\IWDG;..\..\User\SPI;..\..\Hardware\DHT11;..\..\Hardware\OLED;..\..\Libraries\sys;..\..\User\delay;..\..\User\ADC;..\..\Hardware\MQ_2;..\..\Hardware\HC-SR501;..\..\Hardware\HC-SR04;..\..\User\TIMER;..\..\User\EXTI;..\..\User\TIMER\TIM4-capture;..\..\User\I2C;..\..\Hardware\BH1750;..\..\User\NVIC;..\..\User\Contiki-ProcessTask;..\..\Hardware\RC522;..\..\Libraries\cJSON;..\..\Libraries\Malloc;..\..\User\CommunicationProtocol;..\..\User\FIFO;..\..\Hardware\E30TTL100;..\..\Hardware\SDS01;..\..\Hardware\SHT15;..\..\Hardware\T6603;..\..\Hardware\W5500;..\..\User\STM_FLASH;..\..\Hardware\ESP8266;..\..\Hardware\Beep;..\..\User\PWM;..\..\Hardware\MQ_135
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/usart/: bsp_usart1.c bsp_usart2.c
    ../../User/gpio/: bsp_gpio.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/DMA/: dma.c
    ../../User/contiki-code/cpu/arm/stm32f103/: clock.c debug-uart.c
    ../../User/IWDG/: iwdg.c
    ../../User/SPI/: SPI.c
    ../../User/delay/: delay.c
    ../../User/ADC/: adc.c
    ../../User/TIMER/: timers.c
    ../../User/TIMER/TIM4-capture/: timer4_cap.c
    ../../User/I2C/: i2c.c
    ../../User/NVIC/: NVIC_CONFIG.C
    ../../Libraries/cJSON/: cJSON.c
    ../../User/USART/: bsp_usart3.c bsp_uart4.c bsp_uart5.c
    ../../User/STM_FLASH/: stm_flash.c
    ../../User/PWM/: PWM.c
  group contik_core_sys
    ../../User/contiki-code/core/sys/: autostart.c etimer.c process.c procinit.c timer.c
    ../../User/SysTick/: contiki_delay.c
    ../../User/Contiki-ProcessTask/: ProcessTask.c
  group Documents
    ../../Hardware/MQ_2/: MQ-2_GPIO.txt
    ../../Documents/: readme.txt
    ../../Hardware/OLED/: OLED_GPIO.txt
    ../../Hardware/DHT11/: DHT11_GPIO.txt
    ../../Hardware/HC-SR501/: HC-SR501_GPIO.txt
    ../../Hardware/HC-SR04/: HC-SR04_GPIO.txt
    ../../Hardware/BH1750/: BH1750_GPIO.txt
    ../../Hardware/RC522/: RC522_GPIO.txt
    ../../Hardware/E30TTL100/: E30TTLUART_GPIO.txt
    ../../Hardware/SDS01/: SDS01_GPIO.txt
    ../../Hardware/SHT15/: SHT15_GPIO.txt
    ../../Hardware/W5500/: W5500_GPIO.txt
    ../../Hardware/ESP8266/: ESP8266_WIFI_GPIO.txt
    ../../Hardware/Beep/: Beep_GPIO.txt
  group Hardware
    ../../Hardware/OLED/: oled.c
    ../../Hardware/DHT11/: dht11.c
    ../../Hardware/MQ_2/: MQ-2.c
    ../../Hardware/HC-SR501/: HC-SR501.c
    ../../Hardware/HC-SR04/: HC-SR04.c
    ../../Hardware/BH1750/: bh1750.c
    ../../Hardware/RC522/: RC522.c
    ../../Hardware/E30TTL100/: E30TTLUART.c
    ../../Hardware/SDS01/: SDS01.c
    ../../Hardware/SHT15/: SHT15.c
    ../../Hardware/T6603/: T6603.c
    ../../Hardware/W5500/: W5500.c
    ../../Hardware/ESP8266/: ESP8266_config.c ESP8266_function.c ESP8266_Wifi_link_Config.c
    ../../Hardware/Beep/: Beep.c
    ../../Hardware/MQ_135/: MQ-135.c
  group CommunicationProtocol
    ../../User/CommunicationProtocol/: CommunicationProtocol.c CommunicationConfig.c CommunicationDealPacket.c
  group FIFO
    ../../User/FIFO/: FIFO.c Uint8PacketQueueManger.c
